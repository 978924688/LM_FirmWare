# Keil uVision project iSO-STM32.uvprojx, settings and files
target AD7606 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf.exe   --bin -o  ..\..\Output\app.bin ..\..\Output\app.axf
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\User\SysTick;..\..\BSP\TIM;..\..\BSP\sys;..\..\BSP\AD7606;..\..\BSP\dac7565;..\..\BSP\AD5551;..\..\BSP\UART;..\..\BSP\database;..\..\BSP\EXTI;..\..\BSP\ADS1118;..\..\BSP\AT24C02
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../../BSP/TIM/: m_timer.c
    ../../BSP/sys/: sys.c
    ../../BSP/AD7606/: ad7606.c
    ../../BSP/dac7565/: dac7565.c
    ../../BSP/AD5551/: ad5551.c
    ../../BSP/database/: database.c
    ../../BSP/EXTI/: bsp_switch_exti.c
    ../../BSP/ADS1118/: spi_ads1118.c
    ../../BSP/AT24C02/: bsp_i2c_ee.c bsp_i2c_gpio.c
    ../../BSP/UART/: m_usart1.c m_usart3.c m_usart2.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h app.c
    ../../User/Led/: bsp_led.c
    ../../User/SysTick/: bsp_SysTick.c
  group DOC
    ../../Doc/: readme.txt
software components: CMSIS:CORE 5.1.2
